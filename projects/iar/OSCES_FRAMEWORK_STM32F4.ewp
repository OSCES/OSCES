# IAR project OSCES_FRAMEWORK_STM32F4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZG ST STM32F429ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.PreInclude: ..\..\..\thirdparty\STM32F4\STM32F4xx_StdPeriph_Driver\stm32f4xx_conf.h
  ICCARM.CCIncludePath2: ..\..\..\thirdparty\CMSIS\Include; ..\..\..\thirdparty\STM32F4\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\thirdparty\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\thirdparty\STM32F4\STM32F4xx_StdPeriph_Driver; ..\..\..\thirdparty\STM32F4\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\platform\OscesBoard\Drivers; ..\..\..\platform\OscesBoard\System; ..\..\..\platform\OscesBoard\System\Display; ..\..\..\include; ..\..\..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: OSCES.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: OSCES_FRAMEWORK_STM32F4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ../../../platform/OscesBoard/: OscesFrameworkPlatform.cpp
  group crossplatform/GraphicalPrimitives
    ../../../crossplatform/GraphicalPrimitives/: Line.cpp Surface.cpp
  group crossplatform/System/Display
    ../../../crossplatform/System/Display/: Display.cpp Display.h
  group crossplatform/System/Keyboard
    ../../../crossplatform/System/Keyboard/: Keyboard.cpp
  group crossplatform/System/SysTick
    ../../../crossplatform/System/SysTimer/: SysTimer.cpp
  group include
    ../../../include/: DisplayInterface.h DisplayTypes.h KeyboardInterface.h KeyCode.h System.h SysTimerInterface.h ThreadInterface.h
  group platform/Drivers
    ../../../platform/OscesBoard/Drivers/: DmaDriver.cpp FsmcDriver.cpp GpioDriver.cpp InterruptManager.cpp SdioDriver.cpp SysTimerDriver.cpp VirtualPort.cpp VirtualPort.h
  group platform/Kernel
    ../../../platform/OscesBoard/Kernel/: Context.cpp ContextSwitcher.cpp Kernel.cpp MemoryManager.cpp SchedulerPlatform.cpp ThreadPlatform.cpp
  group platform/System
    ../../../platform/OscesBoard/System/FileSystem/: FileSystem.cpp SdCardDriver.cpp
  group platform/System/Buttons
    ../../../platform/OscesBoard/System/Buttons/: buttons.cpp
  group platform/System/ClockManager
    ../../../platform/OscesBoard/System/ClockManager/: ClockManager.cpp
  group platform/System/Display
    ../../../platform/OscesBoard/System/Display/: DisplayPlatform.cpp
  group platform/System/ExtRam
    ../../../platform/OscesBoard/System/ExtRam/: ExtRam.cpp
  group platform/System/Keyboard
    ../../../platform/OscesBoard/System/Keyboard/: PS2KeyboardPlatform.cpp
  group platform/System/Leds
    ../../../platform/OscesBoard/System/Leds/: leds.cpp
  group platform/System/SysTimer
    ../../../platform/OscesBoard/System/SysTimer/: SysTimerPlatform.cpp
  group thirdparty/STM32F4xx_StdPeriph_Driver
    ../../../thirdparty/STM32F4/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
