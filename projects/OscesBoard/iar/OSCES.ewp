# IAR project OSCES.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.PreInclude: ..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\stm32f2xx_conf.h
  ICCARM.CCIncludePath2: ..\..\..\thirdparty\STM32F2\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver; ..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Core\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Class\audio\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Class\dfu\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_HOST_Library\Class\HID\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_HOST_Library\Core\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_OTG_Driver\inc; ..\..\..\thirdparty\STM32F2\STM32_USB_Desc_Conf; ..\..\..\thirdparty\STM32F2\CMSIS\Include; ..\..\..\platform\OscesBoard\Drivers; ..\..\..\platform\OscesBoard\System; ..\..\..\platform\OscesBoard\System\Display; ..\..\..\; ..\..\..\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: OSCES.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f207xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; NDEBUG
  ICCARM.PreInclude: ..\..\thirdparty\STM32F2xx_StdPeriph_Driver\stm32f2xx_conf.h
  ICCARM.CCIncludePath2: ..\..\thirdparty\CMSIS\Device\ST\STM32F2xx\Include; ..\..\thirdparty\STM32F2xx_StdPeriph_Driver; ..\..\thirdparty\STM32F2xx_StdPeriph_Driver\inc; ..\..\thirdparty\STM32_USB_Device_Library\Core\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\audio\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\cdc\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\dfu\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\hid\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\msc\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Class\HID\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Core\inc; ..\..\thirdparty\STM32_USB_OTG_Driver\inc; ..\..\thirdparty\STM32_USB_Desc_Conf; ..\..\thirdparty\CMSIS\Include; ..\..\src\Drivers; ..\..\src; ..\..\src\System; ..\..\src\System\Display
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group crossplatform/System/Display
    ../../../crossplatform/System/Display/: Display.cpp
  group crossplatform/System/Keyboard
    ../../../crossplatform/System/Keyboard/: Keyboard.cpp
  group crossplatform/System/SysTick
    ../../../crossplatform/System/SysTimer/: SysTimer.cpp
  group include
    ../../../include/: DisplayInterface.h KeyboardInterface.h KeyCode.h OscesFrameworkInterface.h SysTimerInterface.h
  group platform
    ../../../platform/OscesBoard/: OscesFramework.cpp
  group platform/Drivers
    ../../../platform/OscesBoard/Drivers/: FsmcDriver.cpp GpioDriver.cpp InterruptManager.cpp SdioDriver.cpp SysTimerDriver.cpp VirtualPort.cpp VirtualPort.h
  group platform/System
    ../../../platform/OscesBoard/System/FileSystem/: FileSystem.cpp SdCardDriver.cpp
  group platform/System/Buttons
    ../../../platform/OscesBoard/System/Buttons/: buttons.cpp
  group platform/System/ClockManager
    ../../../platform/OscesBoard/System/ClockManager/: ClockManager.cpp
  group platform/System/Display
    ../../../platform/OscesBoard/System/Display/: DisplayPlatform.cpp
  group platform/System/ExtRam
    ../../../platform/OscesBoard/System/ExtRam/: ExtRam.cpp
  group platform/System/Keyboard
    ../../../platform/OscesBoard/System/Keyboard/: PS2KeyboardPlatform.cpp
  group platform/System/Leds
    ../../../platform/OscesBoard/System/Leds/: leds.cpp
  group platform/System/SysTimer
    ../../../platform/OscesBoard/System/SysTimer/: SysTimerPlatform.cpp
  group thirdparty/STM32F2xx_StdPeriph_Driver
    ../../../thirdparty/STM32F2/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
