<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>src</name>
    <group>
      <name>Drivers</name>
      <group>
        <name>CMSIS</name>
        <group>
          <name>EWARM</name>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\cmsis\device\st\stm32f2xx\Source\Templates\system_stm32f2xx.c</name>
        </file>
      </group>
      <group>
        <name>STM32F2xx_StdPeriph_Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\drivers\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\FsmcDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\FsmcDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\GpioDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\GpioDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\GpioTypes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\InterruptManager.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\InterruptManager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\SdioDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\SdioDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\stm32f2xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\stm32f2xx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\SysTimerDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\SysTimerDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\VirtualPort.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\VirtualPort.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\drivers\VirtualPortTypes.h</name>
      </file>
    </group>
    <group>
      <name>System</name>
      <group>
        <name>Buttons</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Buttons\buttons.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Buttons\buttons.h</name>
        </file>
      </group>
      <group>
        <name>ClockManager</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\ClockManager\ClockManager.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\ClockManager\ClockManager.h</name>
        </file>
      </group>
      <group>
        <name>Display</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Display\display.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Display\display.h</name>
        </file>
      </group>
      <group>
        <name>ExtRam</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\ExtRam\extram.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\ExtRam\extram.h</name>
        </file>
      </group>
      <group>
        <name>FileSystem</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\fat32.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\fat32.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\FileSystem.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\FileSystem.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\ntfs.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\ntfs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\SdCardDriver.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\FileSystem\SdCardDriver.h</name>
        </file>
      </group>
      <group>
        <name>Keyboard</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\Keyboard.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\Keyboard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\KeyboardInterface.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\KeyCodes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\PS2Keyboard.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Keyboard\PS2Keyboard.h</name>
        </file>
      </group>
      <group>
        <name>Leds</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Leds\leds.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\Leds\leds.h</name>
        </file>
      </group>
      <group>
        <name>MemTest</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\MemTest\MemTest.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\MemTest\MemTest.h</name>
        </file>
      </group>
      <group>
        <name>SysTimer</name>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\SysTimer\systimer.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\src\system\SysTimer\systimer.h</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\src\main.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\Snake.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\Snake.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\SnakeItem.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\SnakeItem.h</name>
    </file>
  </group>
</project>


