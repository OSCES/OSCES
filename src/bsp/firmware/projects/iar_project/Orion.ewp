# IAR project Orion.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.PreInclude: stm32f2xx_conf.h
  ICCARM.CCIncludePath2: ..\..\src\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\src\Drivers\STM32F2xx_StdPeriph_Driver; ..\..\src\Drivers\STM32F2xx_StdPeriph_Driver\inc; ..\..\src\Drivers\CMSIS\Include; ..\..\src\Drivers; ..\..\src\System; ..\..\src\System\Buttons; ..\..\src\System\Display; ..\..\src\System\ExtRam; ..\..\src\System\FileSystem; ..\..\src\System\Keyboard; ..\..\src\System\Leds; ..\..\src\System\SysTimer; ..\..\src\System\MemTest; ..\..\src\System; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Orion.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f207xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group src
    ../../src/: main.cpp Snake.cpp Snake.h SnakeItem.cpp SnakeItem.h
  group src/Drivers
    ../../src/drivers/: FsmcDriver.cpp FsmcDriver.h GpioDriver.cpp GpioDriver.h GpioTypes.h InterruptManager.cpp InterruptManager.h SdioDriver.cpp SdioDriver.h stm32f2xx_it.c stm32f2xx_it.h SysTimerDriver.cpp SysTimerDriver.h VirtualPort.cpp VirtualPort.h VirtualPortTypes.h
  group src/Drivers/CMSIS
    ../../src/drivers/cmsis/device/st/stm32f2xx/Source/Templates/: system_stm32f2xx.c
  group src/Drivers/STM32F2xx_StdPeriph_Driver
    ../../src/drivers/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group src/System/Buttons
    ../../src/system/Buttons/: buttons.cpp buttons.h
  group src/System/ClockManager
    ../../src/system/ClockManager/: ClockManager.cpp ClockManager.h
  group src/System/Display
    ../../src/system/Display/: display.cpp display.h
  group src/System/ExtRam
    ../../src/system/ExtRam/: extram.cpp extram.h
  group src/System/FileSystem
    ../../src/system/FileSystem/: fat32.cpp fat32.h FileSystem.cpp FileSystem.h ntfs.cpp ntfs.h SdCardDriver.cpp SdCardDriver.h
  group src/System/Keyboard
    ../../src/system/Keyboard/: Keyboard.cpp Keyboard.h KeyboardInterface.h KeyCodes.h PS2Keyboard.cpp PS2Keyboard.h
  group src/System/Leds
    ../../src/system/Leds/: leds.cpp leds.h
  group src/System/MemTest
    ../../src/system/MemTest/: MemTest.cpp MemTest.h
  group src/System/SysTimer
    ../../src/system/SysTimer/: systimer.cpp systimer.h
