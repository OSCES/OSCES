<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>crossplatform</name>
    <group>
      <name>System</name>
      <group>
        <name>Display</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\crossplatform\System\Display\Display.cpp</name>
        </file>
      </group>
      <group>
        <name>Keyboard</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\crossplatform\System\Keyboard\Keyboard.cpp</name>
        </file>
      </group>
      <group>
        <name>SysTick</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\crossplatform\System\SysTimer\SysTimer.cpp</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>include</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\DisplayInterface.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\KeyboardInterface.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\KeyCode.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\OscesFrameworkInterface.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\SysTimerInterface.h</name>
    </file>
  </group>
  <group>
    <name>platform</name>
    <group>
      <name>Drivers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\DmaDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\FsmcDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\GpioDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\InterruptManager.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\SdioDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\SysTimerDriver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\VirtualPort.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Drivers\VirtualPort.h</name>
      </file>
    </group>
    <group>
      <name>Kernel</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Kernel\ThreadKernel.cpp</name>
      </file>
    </group>
    <group>
      <name>System</name>
      <group>
        <name>Buttons</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\Buttons\buttons.cpp</name>
        </file>
      </group>
      <group>
        <name>ClockManager</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\ClockManager\ClockManager.cpp</name>
        </file>
      </group>
      <group>
        <name>Display</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\Display\DisplayPlatform.cpp</name>
        </file>
      </group>
      <group>
        <name>ExtRam</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\ExtRam\ExtRam.cpp</name>
        </file>
      </group>
      <group>
        <name>FileSystem</name>
      </group>
      <group>
        <name>Keyboard</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\Keyboard\PS2KeyboardPlatform.cpp</name>
        </file>
      </group>
      <group>
        <name>Leds</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\Leds\leds.cpp</name>
        </file>
      </group>
      <group>
        <name>SysTimer</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\SysTimer\SysTimerPlatform.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\FileSystem\FileSystem.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\System\FileSystem\SdCardDriver.cpp</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\Application.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\OscesBoard\OscesFramework.cpp</name>
    </file>
  </group>
  <group>
    <name>thirdparty</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>EWARM</name>
      </group>
    </group>
    <group>
      <name>STM32_USB_Desc_Conf</name>
    </group>
    <group>
      <name>STM32_USB_Device_Library</name>
      <group>
        <name>Class</name>
        <group>
          <name>Cdc</name>
        </group>
        <group>
          <name>Hid</name>
        </group>
      </group>
      <group>
        <name>Core</name>
      </group>
    </group>
    <group>
      <name>STM32_USB_HOST_Library</name>
      <group>
        <name>Class</name>
      </group>
      <group>
        <name>Core</name>
      </group>
    </group>
    <group>
      <name>STM32_USB_OTG_Driver</name>
      <group>
        <name>Class</name>
      </group>
      <group>
        <name>Core</name>
      </group>
    </group>
    <group>
      <name>STM32F2xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\thirdparty\STM32F2\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
      </file>
    </group>
  </group>
</project>


