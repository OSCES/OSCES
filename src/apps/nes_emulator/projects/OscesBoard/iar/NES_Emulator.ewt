<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>GameConsole</name>
    <group>
      <name>Apu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\Apu.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\Apu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\ApuRegisters.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\ApuRegisters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\NoiseGenerator.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\NoiseGenerator.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\SquareGenerator.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\SquareGenerator.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\TriangleGenerator.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Apu\TriangleGenerator.h</name>
      </file>
    </group>
    <group>
      <name>Cartridge</name>
      <group>
        <name>Mappers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\AoRom.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\AoRom.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\CartridgeMapperTypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\IMapper.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\IMapper.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\Mmc1.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\Mmc1.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\Mmc3.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\Mmc3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\NoRom.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\NoRom.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\UnRom.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Mappers\UnRom.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Cartridge.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\Cartridge.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\GameRomAnaliser.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cartridge\GameRomAnaliser.h</name>
      </file>
    </group>
    <group>
      <name>Control</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Control\Control.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Control\Control.h</name>
      </file>
    </group>
    <group>
      <name>Cpu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\Cpu.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\Cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\CpuOpCodes.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\CpuOpCodes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\CpuRegisters.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Cpu\CpuRegisters.h</name>
      </file>
    </group>
    <group>
      <name>Ppu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\Ppu.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\Ppu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\PpuPalette.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\PpuPalette.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\PpuRegisters.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\GameConsole\Ppu\PpuRegisters.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\GameConsole\GameConsole.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\GameConsole\GameConsole.h</name>
    </file>
  </group>
  <group>
    <name>Games</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\src\Games\Balloon_Fight.cpp</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\src\Emulator.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\src\Emulator.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\src\main.cpp</name>
  </file>
</project>


