# IAR project OSCES.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\thirdparty\STM32F2\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\thirdparty\STM32; H:\OscesRepo\OSCES-FRAMEWORK\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: OSCES.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: OSCES.icf
  ILINK.IlinkAdditionalLibs: H:\OscesRepo\OSCES-FRAMEWORK\build\OscesBoard\libOSCES.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; NDEBUG
  ICCARM.PreInclude: ..\..\thirdparty\STM32F2xx_StdPeriph_Driver\stm32f2xx_conf.h
  ICCARM.CCIncludePath2: ..\..\thirdparty\CMSIS\Device\ST\STM32F2xx\Include; ..\..\thirdparty\STM32F2xx_StdPeriph_Driver; ..\..\thirdparty\STM32F2xx_StdPeriph_Driver\inc; ..\..\thirdparty\STM32_USB_Device_Library\Core\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\audio\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\cdc\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\dfu\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\hid\inc; ..\..\thirdparty\STM32_USB_Device_Library\Class\msc\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Class\HID\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\thirdparty\STM32_USB_HOST_Library\Core\inc; ..\..\thirdparty\STM32_USB_OTG_Driver\inc; ..\..\thirdparty\STM32_USB_Desc_Conf; ..\..\thirdparty\CMSIS\Include; ..\..\src\Drivers; ..\..\src; ..\..\src\System; ..\..\src\System\Display
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ../../../src/: main.cpp Snake.cpp SnakeItem.cpp
